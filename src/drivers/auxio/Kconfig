## src/drivers/auxio/Kconfig
```kconfig
menuconfig DRIVERS_AUXIO
	bool "auxio"
	default n
	---help---
		Enable support for auxio
```
